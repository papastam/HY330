options:
  parameters:
    author: chris
    generate_options: qt_gui
    id: lab5_3
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bitsPbyte
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_descriptor_source_0
  id: blocks_file_descriptor_source
  parameters:
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/chris/Classes/HY330/assignment5/CS_330_Assignment_5_Modulation__GNU_Radio_Development.pdf
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: bitsPbyte
  states: {}
- name: chris_module_constellation_mapping_4569_0
  id: chris_module_constellation_mapping_4569
  parameters:
    mod_bits_cnt: bitsPbyte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    label1: Constellated Signal
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Actual Signal
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Const. Signal Re
    label2: Const. Signal Im
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_descriptor_source_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_pack_k_bits_bb_0, '0', chris_module_constellation_mapping_4569_0, '0']
- [chris_module_constellation_mapping_4569_0, '0', qtgui_const_sink_x_0, '0']
- [chris_module_constellation_mapping_4569_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
