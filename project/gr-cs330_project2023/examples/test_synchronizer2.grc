options:
  parameters:
    author: zoe
    generate_options: qt_gui
    id: test_synchronizer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_UNIFORM
    mean: '1000'
    msg: pmt.intern("TEST")
    std: '1000'
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '8'
    lengthtagname: packet_len
    type: float
  states: {}
- name: cs330_project2023_frame_sync_0
  id: cs330_project2023_frame_sync
  parameters:
    mod: '0'
    preamble: '0xAA'
    preamble_len: '64'
    sync_word: '[0x58, 0x9A]'
  states: {}
- name: cs330_project2023_framer_0
  id: cs330_project2023_framer
  parameters:
    preamble: '0xAA'
    preamble_len: '64'
    sync_word: '[0x58, 0x9A]'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: '1000'
    pre_padding: '0'
    type: float
    window: ([])
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_crc32_async_bb_0_0
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '1000'
    minsize: '50'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_message_strobe_random_0, strobe, pdu_random_pdu_0, generate]
- [blocks_packed_to_unpacked_xx_0, '0', digital_map_bb_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', digital_burst_shaper_xx_0, '0']
- [cs330_project2023_frame_sync_0, pdu, blocks_message_debug_0, print_pdu]
- [cs330_project2023_frame_sync_0, pdu, digital_crc32_async_bb_0_0, in]
- [cs330_project2023_framer_0, frame, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_binary_slicer_fb_0, '0', cs330_project2023_frame_sync_0, '0']
- [digital_burst_shaper_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_burst_shaper_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_crc32_async_bb_0, out, cs330_project2023_framer_0, pdu]
- [digital_crc32_async_bb_0_0, out, blocks_message_debug_0, print_pdu]
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [network_socket_pdu_0, pdus, digital_crc32_async_bb_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [pdu_random_pdu_0, pdus, digital_crc32_async_bb_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
